# Keil uVision project ZOS.uvprojx, settings and files
target ZOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\code\driver;.\code\scheduler;.\code\application
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./code/application/: main.c isr_handler.c task.c
  group scheduler
    ./code/scheduler/: scheduler.c systick_handler.c scheduler.s
  group driver
    ./code/driver/: gpio.c uart.c systick.c
  group start
    ./code/start/: start.s init.c
